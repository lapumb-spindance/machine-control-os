# Hardocde the SRCREV to the latest commit in the master branch, which is known to be working and utilizes
# gstreamer to implement the audioplayers:^5.0.0 plugin.
SRCREV = "bb66b3332da0b05650b865e804045b121f469155"
PV = "1.0+git${SRCPV}"
