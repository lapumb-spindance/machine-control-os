# Override AUTOREV and replace with the latest stable tag.
SRCREV = "c22c4ff9ebd7b79e7e8a951e9831fda2bbf8a281"

PV = "1.0+git${SRCPV}"
