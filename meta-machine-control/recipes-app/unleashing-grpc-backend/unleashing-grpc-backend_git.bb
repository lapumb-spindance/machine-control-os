PUBSPEC_APPNAME = "backend"
inherit unleashing-grpc
