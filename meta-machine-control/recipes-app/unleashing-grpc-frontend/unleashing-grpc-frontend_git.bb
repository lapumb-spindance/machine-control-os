PUBSPEC_APPNAME = "frontend"
inherit unleashing-grpc
